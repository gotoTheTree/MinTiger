# Keil uVision project AT32F421G8U7_G8_ALL.uvprojx, settings and files
target AT32F421G8U7_G8_ALL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F421G8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F421G8U7_G8_ALL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421G8U7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*_IRQHandler
--keep=*_Handler
  group user
    ../src/: at32f421_wk_config.c main.c wk_system.c wk_tmr.c wk_adc.c wk_cmp.c wk_usart.c wk_gpio.c wk_dma.c Music.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_cmp.c at32f421_tmr.c at32f421_gpio.c at32f421_usart.c at32f421_pwc.c at32f421_adc.c at32f421_dma.c at32f421_debug.c at32f421_flash.c at32f421_exint.c at32f421_misc.c at32f421_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group Servo_Lib
    ../V1LIB/: Servo_LIB_V1.lib
